# Keil uVision project STC8_AlibabaCloud.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8_AlibabaCloud +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Code\Basic\def;.\Code\Basic\delay;.\Code\Basic\init;.\Code\Basic\uart;.\Code\Sensor\DS18B20;.\Code\Sensor\LCD1602;.\Code\AlibabaCloud
  link misc: REMOVEUNUSED
  group Main
    ./Code/: main.c
  group Basic
    ./Code/Basic/: ISR.c
    ./Code/Basic/uart/: uart.c
    ./Code/Basic/init/: Init.c
    ./Code/Basic/delay/: delay.c
  group Sensor
    ./Code/Sensor/DS18B20/: DS18B20.c
    ./Code/Sensor/LCD1602/: LCD1602.c
  group AlibabaCloud
    ./Code/AlibabaCloud/: CloudHandle.c CloudCodeArray.c
